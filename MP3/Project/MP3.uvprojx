# Keil uVision project MP3.uvprojx, settings and files
target MP3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MP3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx
  c include: ..\Library\CMSIS\Device\STM32F4xx\Include;..\Library\CMSIS\Include;..\Library\CMSIS\startup;..\Library\User_Libraries\inc;..\Library\tm_stm32f4_fatfs\fatfs;..\Library\tm_stm32f4_fatfs\fatfs\drivers;..\Library\tm_stm32f4_fatfs\fatfs\option;..\Library\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group source
    ../User/: main.c
  group fatfs
    ../Library/tm_stm32f4_fatfs/: tm_stm32f4_fatfs.c
    ../Library/tm_stm32f4_fatfs/fatfs/: tm_stm32f4_gpio.c ff.c diskio.c
    ../Library/tm_stm32f4_fatfs/fatfs/option/: syscall.c unicode.c
    ../Library/tm_stm32f4_fatfs/fatfs/drivers/: fatfs_sd_sdio.c
  group Standard peripheral libaries
    ../Library/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c misc.c stm32f4xx_dac.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group user
    ../Library/User_Libraries/src/: delay.c uart.c timer.c dac.c button.c app.c dma.c clock.c sd_card.c adc.c flash.c lcd16x2.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.6.3
